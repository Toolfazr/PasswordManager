# Keil uVision project password_manager.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: password_manager
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER __cpluscplus
  c include: ..\ThirdParty\FreeRTOS\portable\RVDS\ARM_CM3;..\ThirdParty\FreeRTOS\include;..\ThirdParty\FreeRTOS;..\ThirdParty\STM32_Std_Lib\Core;..\ThirdParty\STM32_Std_Lib\Lib;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group freerots_src
    ../ThirdParty/FreeRTOS/: FreeRTOSConfig.h tasks.c event_groups.c list.c timers.c queue.c
    ../ThirdParty/FreeRTOS/include/: FreeRTOS.h portable.h projdefs.h task.h event_groups.h list.h timers.h queue.h semphr.h
    ../ThirdParty/FreeRTOS/portable/RVDS/ARM_CM3/: portmacro.h port.c
    ../ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
  group stm32_lib
    ../ThirdParty/STM32_Std_Lib/core/: stm32f10x.h stm32f10x_it.c stm32f10x_it.h
    ../ThirdParty/STM32_Std_Lib/lib/: stm32f10x_rcc.h stm32f10x_usart.h stm32f10x_spi.h stm32f10x_gpio.h stm32f10x_exti.h misc.h misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group driver_and_application
    ../Inc/: bus.h os.h interrupt_support.h data_type.h finger_sensor.h communicator.h storage_media.h password_manager.h
    ../Src/: bus.cpp os.cpp interrupt_support.cpp data_type.cpp finger_sensor.cpp communicator.cpp storage_media.cpp password_manager.cpp
  group main
    ../Src/: main.cpp
    ../ThirdParty/STM32_Std_Lib/core/: startup_stm32f10x_md.s
